Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Capri-Living Armchair - ver4.ifc
Time: 2024-12-10T14:27:14
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (5)
Name
 | Capri-Living Armchair_0 - ObjectType: SketchupGroup
 | Capri-Living Armchair_1 - ObjectType: SketchupGroup
 | Capri-Living Armchair_2 - ObjectType: SketchupGroup
 | Capri-Living Armchair_3 - ObjectType: SketchupGroup
 | Capri-Living Armchair_4 - ObjectType: SketchupGroup
